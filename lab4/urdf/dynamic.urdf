Commit message: lab4

File: lab4/urdf/dynamic.urdf (robot description, URDF)
Before this commit: robot test_robot, 6 links, 5 joints
Links:
- link link2: geometry visual sphere radius=0.1
